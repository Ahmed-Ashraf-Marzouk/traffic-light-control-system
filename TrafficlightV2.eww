<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>G:\Semester 7\Embedded\FinalProject\CESS_Team4_Trafficlight\TrafficLight.ewp</path>
    </project>
    <batchBuild />
</workspace>
